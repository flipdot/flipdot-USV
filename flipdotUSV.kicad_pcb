# Repository flipdot/flipdot-USV

File README.md:

Raspberry Pi Hat Template based on http://gitlab.openfet.com/julien/pihat-template

Schematics based on http://flipdot.org/blog/archives/348-USV-fuer-raspberry-Pi-11.-Juni-2016,-2000.html

## KiCad design flipdotUSV.kicad_pcb

Parts:
C1: 47uF; CP_Elec_10x10
C2, C3: 1mF; CP_Elec_10x10
C4: 10n; C_0805_HandSoldering
C5: 100n; C_0805_HandSoldering
C6: DNL; CP_Elec_10x10
C7: 100nF; C_0805_HandSoldering
D1, D2, D3, D5: SB120; D_SMA_Handsoldering
D4: D_Schottky; D_SMB-SMC_Universal_Handsoldering
IC1: ATTINY13-S; SOIJ-8_5.3x5.3mm_Pitch1.27mm
L1: 33uH; Choke_SMD_12x12mm_h8mm
P2, P4: CONN_01X02; AK300-2; Mouser Part No. 651-1904383
P3: Raspberry_Pi_+_Conn; IDC_Header_Straight_40pins; Mouser Part No. 517-30340-6002
Q1: BC547; TO-92_Inline_Wide
R1, R3, R4, R7: 1k; R_0805_HandSoldering
R2: 33R; R_Axial_Power_L25.0mm_W6.4mm_P30.48mm
R5: 2k2; R_0805_HandSoldering
R6: 3k3; R_0805_HandSoldering
R8: 330k; R_0805_HandSoldering
R9: 100k; R_0805_HandSoldering
RL1: HFD2-L2
U1: LM2596S-5; TO-263-5Lead

Connections:
+5V: C3.1, C4.1, C5.1, C6.1, C7.1, D1.1 (K), D5.1 (K), IC1.8 (VCC), L1.1, P3.2 (VPP_(5v)), P3.4 (VPP_(5v)), RL1.2, U1.4 (FB); also elsewhere on the board
+14V: C1.1, D2.2 (A), P4.1, R1.1, R3.1
+BATT: D3.2 (A), P2.1, R2.1, RL1.4
Batt_Voltage: R8.1, RL1.8
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D4.2 (A), IC1.4 (GND), P2.2, P3.6 (GND), P3.9 (GND), P3.14 (GND), P3.20 (GND), P3.25 (GND), P3.30 (GND), P3.34 (GND), P3.39 (GND), P4.2, Q1.3 (E), R4.2, R6.2, R9.2, RL1.16, U1.3 (GND), U1.5 (~ON~/OFF); also elsewhere on the board
unnamed: C1.2, R1.2, RL1.1
unnamed: C2.1, RL1.9, U1.1 (VIN)
unnamed: D2.1 (K), D3.1 (K), R2.2, RL1.13
unnamed: D4.1 (K), L1.2, U1.2 (OUT)
unnamed: Q1.2 (B), R7.2
RPI_READBACK: IC1.2 (PB3(CLKI/ADC3/PCINT3)), P3.11 (GPIO17)
RPI_SHUTDOWN: P3.13 (GPIO27), R5.2, R6.1
RST: IC1.1 (PB5(~RESET~/ADC0/PCINT5/dW)); also elsewhere on the board
Rel_off: D1.2 (A), Q1.1 (C), RL1.15
Voltage: IC1.3 (PB4(ADC2/PCINT4)), R8.2, R9.1
miso: IC1.6 (PB1(MISO/AIN1/OC0B/INT0/PCINT1)), R5.1; also elsewhere on the board
mosi: D5.2 (A), IC1.5 (PB0(MOSI/AIN0/OC0A/PCINT0)), R3.2, R4.1; also elsewhere on the board
sck: IC1.7 (PB2(SCK/ADC1/T0/PCINT2)), R7.1; also elsewhere on the board

Board: 2 copper layers, 65.0 x 56.5 mm, 30 parts (2 on the bottom side), 18 nets.

Other parts of the board:
CON1: AVR-ISP-6; IDC_Header_Straight_6pins

Their connections:
+5V: CON1.2; also elsewhere on the board
GND: CON1.6; also elsewhere on the board
RST: CON1.5; also elsewhere on the board
miso: CON1.1; also elsewhere on the board
mosi: CON1.4; also elsewhere on the board
sck: CON1.3; also elsewhere on the board

## Commit log

2016-07-03 init
2016-07-03 added schematic as pdf
2016-07-04 added voltage measurement
2017-02-25 add Layout
2017-03-19 fixed footprint fuckup
2017-03-19 add isp port

Notices in the files:
flipdotUSV.kicad_pcb:
License: CERN OHL V1.2
